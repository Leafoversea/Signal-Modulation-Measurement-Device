# Keil uVision project AD9959.uvprojx, settings and files
target AD9959 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AD9959 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CMSIS\Include;..\CMSIS\Device;..\Project;..\STM32F1xx_HAL_Driver\Inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c delay.c systemclk.c stm32f1xx_it.c
    ../CMSIS/Device/: system_stm32f1xx.c
  group User
    ../User/LED/: led.c
    ../User/KEY/: key.c
    ../User/USART/: usart.c
    ../User/LCD/: lcd.c
    ../User/AD9959/: ad9959.c ad9959.h
    ../User/TIMER/: gtim.c
    ./: sweep.c sweep.h
    ../User/ADC/: adc.c adc.h
  group HAL_Driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
    ../STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h
  group CMSIS
    ../CMSIS/Device/: startup_stm32f103xe.s
